# IAR project OS.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: FM33A04x FMSH FM33A04x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ; ..\; ..\..\BSP; ..\..\BSP\IAR; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M0\Generic\IAR; ..\..\BSP\Drivers; ..\..\BSP\IncludeIAR; ..\..\BSP\UserCode
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS.srec
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\fm33G0xx_flash.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app.c app_cfg.h app_hooks.c cpu_cfg.h FM33G0XX.h includes.h os_cfg.h system_FM33G0XX.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c system_FM33G0XX.c
    ../../BSP/UserCode/: user_init.c
  group BSP/FM33G0/inc
    ../../BSP/Drivers/: fm33g0xx_aes.h fm33g0xx_anac.h fm33g0xx_btim.h fm33g0xx_conf.h fm33g0xx_crc.h fm33g0xx_dma.h fm33g0xx_etim.h fm33g0xx_flash.h fm33g0xx_gpio.h fm33g0xx_hspi.h fm33g0xx_i2c.h fm33g0xx_iwdt.h fm33g0xx_lcd.h fm33g0xx_lptim.h fm33g0xx_lpuart.h fm33g0xx_pmu.h fm33g0xx_rcc.h fm33g0xx_rtc.h fm33g0xx_scu.h fm33g0xx_spi.h fm33g0xx_trng.h fm33g0xx_u7816.h fm33g0xx_uart.h fm33g0xx_wwdt.h
  group BSP/FM33G0/src
    ../../BSP/Drivers/: fm33g0xx_aes.c fm33g0xx_anac.c fm33g0xx_btim.c fm33g0xx_crc.c fm33g0xx_dma.c fm33g0xx_etim.c fm33g0xx_flash.c fm33g0xx_gpio.c fm33g0xx_hspi.c fm33g0xx_i2c.c fm33g0xx_iwdt.c fm33g0xx_lcd.c fm33g0xx_lptim.c fm33g0xx_lpuart.c fm33g0xx_pmu.c fm33g0xx_rcc.c fm33g0xx_rtc.c fm33g0xx_scu.c fm33g0xx_spi.c fm33g0xx_trng.c fm33g0xx_u7816.c fm33g0xx_uart.c fm33g0xx_wwdt.c
  group BSP/IAR
    ../../BSP/IAR/: cstartup.s
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M0/IAR
    ../../../../../uC-CPU/ARM-Cortex-M0/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-II/Ports/ARM-Cortex-M0/Generic/IAR
    ../../../../../uCOS-II/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
