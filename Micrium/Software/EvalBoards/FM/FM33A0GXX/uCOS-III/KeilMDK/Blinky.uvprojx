# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.2.02
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: OneElfS=1 wLevel=2
  c define: __DEBUG
  c include: ..\..\uCOS-III;..\..\BSP;..\..\BSP\KeilMDK;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M0\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M0\Generic\RealView;..\..\..\..\..\uCOS-III\Source;..\..\BSP\Drivers;..\..\BSP\Include;..\..\BSP\UserCode
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../: app.c os_app_hooks.c
  group BSP
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/: bsp.c bsp_int.c system_FM33G0XX.c
    ../../BSP/UserCode/: user_init.c
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c
    ../../../../../uC-CPU/ARM-Cortex-M0/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III Source
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu_c.c os_cpu_a.s
  group FM33G0xx_Library
    ../../BSP/Drivers/: fm33g0xx_aes.c fm33g0xx_anac.c fm33g0xx_btim.c fm33g0xx_crc.c fm33g0xx_dma.c fm33g0xx_etim.c fm33g0xx_flash.c fm33g0xx_gpio.c fm33g0xx_hspi.c fm33g0xx_i2c.c fm33g0xx_iwdt.c fm33g0xx_lcd.c fm33g0xx_lptim.c fm33g0xx_lpuart.c fm33g0xx_pmu.c fm33g0xx_rcc.c fm33g0xx_rtc.c fm33g0xx_scu.c fm33g0xx_spi.c fm33g0xx_trng.c fm33g0xx_u7816.c fm33g0xx_uart.c fm33g0xx_wwdt.c
